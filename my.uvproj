# Keil uVision project my.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AT91SAM7S256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: my +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Main
    ./: main.c timer.c test_cpp.cpp commons.c
  group Drivers
    ./: TWI.c GPS.c XBee.c USB.c SAM7.s ADC.c SPI.c PWM.c PIO.c PIT.c
  group Modules
    ./: IMU.c Filter.c MotorMixer.c RadioController.c AttitudeEstimator.c PositionEstimator.c Controls.c
  group Devices
    ./: EEPROM.c MS5611_SPI.c MPU6000_SPI.c HMC5883.c
